<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR
  xmlns="http://autosar.org/schema/r4.0"
  xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance"
  xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00051.xsd">
  <ADMIN-DATA>
    <LANGUAGE>EN</LANGUAGE>
    <DOC-REVISIONS>
      <DOC-REVISION>
        <REVISION-LABEL>1.0.0</REVISION-LABEL>
        <ISSUED-BY>arxml-secdiff scenario generator</ISSUED-BY>
        <DATE>2026-11-20T00:00:00Z</DATE>
      </DOC-REVISION>
    </DOC-REVISIONS>
  </ADMIN-DATA>
  <AR-PACKAGES>
    <AR-PACKAGE UUID="32268920-92c6-5a09-8967-ba4dd335744d">
      <SHORT-NAME>S01UCON</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="13bae2a3-c3af-5f98-a966-44f65abc0de5">
          <SHORT-NAME>Comm</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
